# Keil uVision project test-gpio-uart.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::.\ARMCLANG)
  device: DS_CM3 ARM
  pack: Keil.V2M-MPS2_DSx_BSP.1.1.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CortexM3
  AfterMake: fromelf -cvf ./CortexM3.axf --vhx --32x1 -o image.hex
  AfterMake: fromelf -cvf ./CortexM3.axf -o image.txt
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: mian.c main.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
